options:
  parameters:
    author: alex
    generate_options: qt_gui
    id: Main
    output_language: python
    title: Playing the RTL-SDR
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: Center Frequency
    orient: Qt.Horizontal
    start: 85e6
    step: '1'
    stop: 110e6
    value: 107.5e6
  states: {}
- name: lpf_dec
  id: variable
  parameters:
    value: '4'
  states: {}
- name: rf_sample_rate
  id: variable
  parameters:
    value: samp_rate*10*4
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_wfm_rcv_pll_0
  id: analog_wfm_rcv_pll
  parameters:
    audio_decimation: '10'
    quad_rate: rf_sample_rate/lpf_dec
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: plughw:CARD=I82801AAICH,DEV=0
    num_inputs: '2'
    ok_to_block: 'False'
    samp_rate: samp_rate
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '8'
    file: /media/sf_Shared_Folders/GNU_Radio/Output/audio_record.wav
    nchan: '2'
    samp_rate: samp_rate
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: lpf_dec
    gain: '1'
    samp_rate: rf_sample_rate
    type: fir_filter_ccf
    width: 10e3
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: rf_sample_rate
    fc: center_freq
    fftsize: '16383'
    grid: 'True'
    name: '"Full Span Frequency"'
    type: complex
    update_time: '0.1'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: rf_sample_rate/lpf_dec
    fc: '0'
    fftsize: '16383'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: '"rtl=0"'
    bb_gain0: '20'
    freq0: center_freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: rf_sample_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_pll_0, '0', audio_sink_0, '0']
- [analog_wfm_rcv_pll_0, '0', blocks_wavfile_sink_0, '0']
- [analog_wfm_rcv_pll_0, '1', audio_sink_0, '1']
- [analog_wfm_rcv_pll_0, '1', blocks_wavfile_sink_0, '1']
- [low_pass_filter_0, '0', analog_wfm_rcv_pll_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_1, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
